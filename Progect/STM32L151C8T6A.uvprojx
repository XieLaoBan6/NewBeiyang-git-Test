# Keil uVision project STM32L151C8T6A.uvprojx, settings and files
target STM32L151C8T6A (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151C8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32L151C8T6A +hex
  AfterMake: fromelf --bin !L --output ./output/stm32L151C8_rtt.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;..\Applications;..\Drivers\CMSIS;..\Fwlib\StdSnbc;..\Middlewares\MidLed;..\Middlewares\MidUsb;..\Middlewares;..\Drivers\DriversBoard\BspUsb\Inc;..\Drivers\DriversBoard\BspUsb\Src;..\Drivers\DriversBoard\BspPwm;..\Middlewares\MidMotor;..\Middlewares\MidBase64;..\Middlewares\MidSensor;..\Drivers\DriversBoard\BspAdc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MDK-ARM
    ./: startup_stm32l151xba.s
  group Applications
    ../Core/Src/: stm32l1xx_it.c stm32l1xx_hal_msp.c
    ../Applications/: main.c AppProtocol.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_uart.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_ll_usb.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Drives
    ../Drivers/DriversBoard/BspGpio/: BspGpio.c
    ../Drivers/DriversBoard/BspUart/: BspUart.c
    ../Drivers/DriversBoard/BspPwm/: BspPwm.c
    ../Drivers/DriversBoard/BspAdc/: BspAdc.c
  group Fwlib
    ../Fwlib/StdSnbc/: StdFunction.c
  group Middlewares
    ../Middlewares/MidLed/: MidLed.c
    ../Middlewares/MidUsb/: MidUsb.c
    ../Middlewares/MidMotor/: MidMotor.c
    ../Middlewares/MidBase64/: MidBase64.c
    ../Middlewares/MidSensor/: MidSensor.c
  group UsbDrives
    ../Drivers/DriversBoard/BspUsb/Src/: usbd_cdc.c usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
    ../Drivers/DriversBoard/BspUsb/: usbd_cdc_interface.c
software components: CMSIS:CORE 4.3.0
